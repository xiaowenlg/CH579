# Keil uVision project BLE.uvprojx, settings and files
target BLE (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CH579 WCH
  pack: Keil.WCH57x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG,HAL_KEY
  c include: ..\APP\include;..\Profile\include;..\MCUDriver\HAL\include;..\MCUDriver\LIB;..\MCUDriver\SRC\CMSIS\Include;..\MCUDriver\SRC\StdPeriphDriver\inc;..\MCUDriver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ../APP/: peripheral.c peripheral_main.c
  group profile
    ../Profile/: devinfoservice.c gattprofile.c
  group drive
    ../MCUDriver/SRC/Startup/: startup_ARMCM0.s
    ../MCUDriver/SRC/StdPeriphDriver/: CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_int.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c
    ../MCUDriver/HAL/: KEY.c
  group hal
    ../MCUDriver/HAL/: MCU.c RTC.c SLEEP.c DataProcessing.c
  group lib
    ../MCUDriver/LIB/: CH57xBLE.lib
  group config
    ../MCUDriver/HAL/include/: config.h
software components: CMSIS:CORE 5.4.0
